# Keil uVision project lab6lcd.uvprojx, settings and files
target labLCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab6lcd
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group user
    ./user/: AsciiLib.c LCD_ILI9325.c main.c frames.c frames.h game.c game.h
software components: CMSIS:CORE 5.4.0, Device:STM32Cube LL:COMMON 1.9.0, Device:STM32Cube LL:DMA 1.9.0, Device:STM32Cube LL:GPIO 1.9.0, Device:STM32Cube LL:I2C 1.9.0, Device:STM32Cube LL:PWR 1.9.0, Device:STM32Cube LL:RCC 1.9.0, Device:STM32Cube LL:USART 1.9.0, Device:STM32Cube LL:UTILS 1.9.0, Device:Startup 1.0.0
